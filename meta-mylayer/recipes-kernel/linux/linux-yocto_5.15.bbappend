FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://gpio-sysfs.cfg"
#KCONFIG_MODE = "alldefconfig"